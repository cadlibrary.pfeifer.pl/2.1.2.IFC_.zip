Properties of the parts of a building model (IFC4)

# File
Description: no view
File name: SiDi_70.ifc
Time: 2024-10-29T09:37:55
Author: Aleksander Skuła
Organization: No Organization
Written by: ODA SDAI 24.5
Authorization: askula

# IfcBuildingStorey, SiDi
In: PCC_EXPORT
Elevation: 0 m

# IfcBuildingElementProxy, SiDi_70
In: SiDi
Material: S355J2+N
AllplanAttributes - Typ_robót: Roboty betonowe; V6: 0 m; V7: 0 m; V8: 0 m; V9: 0; Nazwa obiektu: COLMSHOE_PFEIFER_SiDi_70; Nazwa: SiDi_70; Materiał: S355J2+N; CATALOG: https://pfeifer.pl/wp-content/uploads/2024/10/COLMSHOE_katalog-techniczny.pdf; MAX_CAPACITY: 70kN; WEBSITE: https://pfeifer.pl/podpory-slupowe-colmshoe/; Marka: PFEIFER; Zestaw atrybutów obiektu: Body; ID_komponentu_Allright: 0409PEb0000000020; Rodzaj rozliczenia: Szt
